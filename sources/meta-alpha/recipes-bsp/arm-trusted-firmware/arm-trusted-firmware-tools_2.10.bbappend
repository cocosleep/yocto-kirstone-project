URL := "git://github.com/cocosleep/arm-trusted-firmware.git;protocol=https"
# BRANCH ?= "${RELEASE_BASE}-${PV}"
BRANCH := "master"

SRCREV = "${AUTOREV}"