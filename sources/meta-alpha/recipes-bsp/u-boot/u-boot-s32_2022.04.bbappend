
URL = "git://github.com/cocosleep/u-boot-s32.git;protocol=https"
BRANCH = "master"

SRCREV = "${AUTOREV}"
