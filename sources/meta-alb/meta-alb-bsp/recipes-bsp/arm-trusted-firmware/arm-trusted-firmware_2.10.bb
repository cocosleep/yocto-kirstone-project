# Copyright 2024 NXP

require recipes-bsp/arm-trusted-firmware/atf-src-${PV}.inc
require recipes-bsp/arm-trusted-firmware/arm-trusted-firmware.inc
